Commit message: Tf_tree correction

File: Minichallenges/minichal1/include/puzzlebot_2.urdf (robot description, URDF)
Before this commit: robot Puzzlebot, 4 links, 3 joints
Links:
- removed link base_link
- added link odom
Joints:
- joint chassis_joint: parent base_link -> odom
